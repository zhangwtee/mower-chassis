# Keil uVision project mower.uvprojx, settings and files
target mower (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mower +hex
  AfterMake: D:\Keil_v5\ARM\ARM_Compiler_5.06u7\Bin\fromelf.exe --bin --output=..\mower.bin ..\OBJ\mower.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_PRESENT=1,__TARGET_FPU_VFP,__CC_ARM
  c include: ..\app;..\bsp;..\cfg;..\cmsis;..\spl\inc;..\rtos\include;..\rtos\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group cmsis
    ../cmsis/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group spl
    ../spl/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_iwdg.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group rtos
    ../rtos/: tasks.c queue.c list.c
    ../rtos/portable/RVDS/ARM_CM4F/: port.c
    ../rtos/portable/MemMang/: heap_4.c
  group app
    ../app/: main.c irq.c protocol.c telemetry.c kinematics.c pi.c chassis_safety.c blade.c chassis.c ring.c speed_smooth.c filter.c app_key.c app_param.c avoid.c params.c params_io.c watchdog.c indicator.c click.c park.c diag.c joy_guard.c link.c chassis_task.c telemetry_task.c imu_task.c hmi_task.c
  group bsp
    ../bsp/: motor.c encoder.c uart.c adc.c servo.c relay.c delay.c i2c.c imu.c oled.c oledfont.c can.c fault.c flash.c iwdg.c led.c buzzer.c key.c
